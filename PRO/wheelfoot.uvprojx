# Keil uVision project wheelfoot.uvprojx, settings and files
target PROJECT (6180000::V6.18::ARMCLANG)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wheelfoot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,DEBUG_ENABLE_SEMIHOST,__TARGET_FPU_VFP
  c include: ..\Library\STM32F4xx_StdPeriph_Driver\inc;..\Library\Include;..\uCOSII\CONFIG;..\uCOSII\CORE;..\uCOSII\PORT;..\Library\CMSIS;..\Library\Startup;..\Hardware\inc;..\Function\inc;..\Main\inc;..\Chassis\inc;..\Motor\inc;..\Sensor\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MASTER
    ../Main/src/: irqhandler.c main.c bluetooth.c masterparam.c
  group FUNCTION
    ../Function/src/: datastruct.c mymath.c pid.c vector.c queue.c vofa.c btoscilloscope.c
  group CHASSIS
    ../Chassis/src/: leg.c robot.c robotparam.c robotmonitor.c
  group SENSOR
    ../Sensor/src/: yesense.c
  group MOTOR
    ../Motor/src/: djmotor.c tmotor.c vesc.c zdrive.c
  group HARDWARE
    ../Hardware/src/: delay.c beep.c can.c led.c led8.c tim.c usart.c
  group LIB
    ../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_it.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c
  group CMSIS
    ../Library/CMSIS/: system_stm32f4xx.c arm_cortexM4lf_math.lib stm32f4xx.h system_stm32f4xx.h
  group STARTUP
    ../Library/Startup/: startup_stm32f4xx.s
  group UCOSII/CORE
    ../uCOSII/CONFIG/: includes.h os_cfg.h
  group UCOSII/CONFIG
    ../uCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group UCOSII/PORT
    ../uCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group README
    ../: readme.md
